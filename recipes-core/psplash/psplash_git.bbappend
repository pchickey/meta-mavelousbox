FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://psplash-rpimavelous-img.h;outsuffix=default"
